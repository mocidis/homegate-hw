<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\RouterVersion1.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>RouterVersion1</project>
        <configuration>CoordinatorEB</configuration>
      </member>
      <member>
        <project>RouterVersion1</project>
        <configuration>RouterEB</configuration>
      </member>
      <member>
        <project>RouterVersion1</project>
        <configuration>EndDeviceEB</configuration>
      </member>
      <member>
        <project>RouterVersion1</project>
        <configuration>RouterZLight</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


